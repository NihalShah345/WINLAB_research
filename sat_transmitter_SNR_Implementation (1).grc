options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_tx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    start: '-3'
    step: '.01'
    stop: '3'
    value: '0'
  states: {}
- name: intSize
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: noisePowerLabel
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,3
    label: 'Noise Power (dBfs): '
    type: real
    value: variable_function_probe_noise
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: signalPowerLabel
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,3
    label: 'Signal Power (dBfs): '
    type: real
    value: variable_function_probe_signal
  states: {}
- name: snr
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,6,1,3
    label: 'SNR (dB): '
    type: real
    value: variable_function_probe_signal-variable_function_probe_noise
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: variable_function_probe_noise
  id: variable_function_probe
  parameters:
    block_id: probeSignalPowerNoise
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_signal
  id: variable_function_probe
  parameters:
    block_id: probeSignalPower
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: |-
      Filter the noise to
      measure it.
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-600e3'
    low_cutoff_freq: '-1000e3'
    samp_rate: 2e6
    type: fir_filter_ccc
    width: 20e3
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Calculate the signal power.
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Calculate the noise power.
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: adv.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/amangrandhi/Downloads/parkrun1920_12mbps.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Average the signal
      power.
    length: intSize
    max_iter: intSize
    scale: 1/intSize
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Average the noise
      power.
    length: intSize
    max_iter: intSize
    scale: 1/intSize
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Convert the signal power 
      to logarithmic (decibel)
      scale.
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Convert the noise power 
      to logarithmic (decibel)
      scale.
    k: '0'
    n: '10'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: freq_offset * 1.0/fft_len
    noise_voltage: noise_voltage
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_NORMAL
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C9_10
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(0.9, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      Filter the FM broadcast
      signal.
    cutoff_freq: 60e3
    decim: '1'
    gain: '1'
    samp_rate: 2e5
    type: ccc
    width: 5e3
    win: window.WIN_BLACKMAN
  states: {}
- name: probeSignalPower
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probeSignalPowerNoise
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"black"'
    color2: '"green"'
    color3: '"red"'
    fc: center_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 1,0,5,10
    label1: RF Spectrum
    label2: Filtered Signal Spectrum
    label3: Filtered Noise Spectrum
    nconnections: '3'
    type: complex
    wintype: window.WIN_FLATTOP
    ymax: '-10'
    ymin: '-110'
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    bandwidth0: '6000000'
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '20'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, ((symbol_rate * (1 + rolloff)) / 2 ) + 1e5)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=256,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: signalSpectrum
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mod-phy
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: noiseSpectrum
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: signalSpectrum
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mod-phy
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: noiseSpectrum
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [band_pass_filter_0, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_nlog10_ff_0, '0', probeSignalPower, '0']
- [blocks_nlog10_ff_0_0, '0', probeSignalPowerNoise, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [channels_channel_model_0, '0', fft_filter_xxx_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_1, '0']
- [dtv_dvbs2_physical_cc_0, '0', channels_channel_model_0, '0']
- [fft_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', soapy_custom_sink_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0_0, '0']
- [fft_filter_xxx_0, '0', virtual_sink_2, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [filter_fft_low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [virtual_source_1, '0', dtv_dvbs2_physical_cc_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0_0, '2']
- [virtual_source_2, '0', blocks_float_to_complex_0, '0']
- [virtual_source_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
